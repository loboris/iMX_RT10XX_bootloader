# Keil uVision project bootloader.uvprojx, settings and files
target qspi_flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --cpu=Cortex-A7 --disassemble --output=@L.dump !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, QSPI_FLASH, NDEBUG, CPU_MIMXRT1052DVL6B, USB_STACK_BM
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ..\board\MIMXRT1052;..\usb;..\user;..\..\..\tools\sdk\CMSIS\Include;..\..\..\tools\sdk\middleware\usb\include;..\..\..\tools\sdk\middleware\usb\osa;..\..\..\tools\sdk\middleware\usb\phy;..\..\..\tools\sdk\middleware\usb\device;..\..\..\tools\sdk\components\uart;..\..\..\tools\sdk\components\serial_manager;..\..\..\tools\sdk\devices\MIMXRT1052;..\..\..\tools\sdk\devices\MIMXRT1052\drivers;..\..\..\tools\sdk\devices\MIMXRT1052\utilities;..\..\..\tools\sdk\devices\MIMXRT1052\utilities\str;..\..\..\tools\sdk\devices\MIMXRT1052\utilities\debug_console;..\..\..\tools\sdk\devices\MIMXRT1052\
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\board\MIMXRT1052\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../user/: app.h app.s bootloader.c
  group imxrt-ba
    ../user/: board_drive_led.c board_drive_led.h flexspi_hyper_flash_ops.c imxrt_ba_cdc.c imxrt_ba_cdc.h imxrt_ba_flash.c imxrt_ba_flash.h imxrt_ba_monitor.c imxrt_ba_monitor.h
  group usb
    ../usb/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h
  group board
    ../board/MIMXRT1052/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group fsl-usb
    ../../../tools/sdk/middleware/usb/phy/: usb_phy.c usb_phy.h
    ../../../tools/sdk/middleware/usb/device/: usb_device.h usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h
    ../../../tools/sdk/middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group startup
    ../board/MIMXRT1052/: startup_MIMXRT1052.s
  group drivers
    ../../../tools/sdk/devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_dcp.c fsl_dcp.h
  group component
    ../../../tools/sdk/components/uart/: lpuart_adapter.c uart.h
    ../../../tools/sdk/components/serial_manager/: serial_port_uart.c serial_port_uart.h serial_manager.c serial_manager.h
  group xip
    ../../../variants/arch_mix/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group utilities
    ../../../tools/sdk/devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../../tools/sdk/devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../tools/sdk/devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group device
    ../../../tools/sdk/devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
target hyper_flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: as above
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, USB_STACK_BM
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\board\MIMXRT1052\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
